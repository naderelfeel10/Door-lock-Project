# IAR project HMI_ECU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\HMI_ECU_DIR\HMI_ECU\MCAL; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\HMI_ECU_DIR\HMI_ECU\HAL; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\HMI_ECU_DIR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HMI_ECU.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HMI_ECU/Application
    HMI_ECU/Application/: HMI_main.c
  group HMI_ECU/HAL
    HMI_ECU/HAL/: keypad.c keypad.h lcd.c lcd.h potentiometer.c potentiometer.h
  group HMI_ECU/MCAL
    HMI_ECU/MCAL/: adc.c dio.c dio.h uart.c uart.h
    ../: adc.h systick.c systick.h
    ./: tm4c123gh6pm.h
