# IAR project tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TEST_MODE
  ICCARM.CCIncludePath2: Application; HAL; MCAL; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\Testing; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\Testing\tests; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\Testing\HAL; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\Testing\MCAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tests.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group HAL
    HAL/: Buzzer.c Buzzer.h keypad.c keypad.h lcd.c lcd.h motor.c motor.h potentiometer.c potentiometer.h
  group MCAL
    MCAL/: adc.c adc.h dio.c dio.h systick.c systick.h tm4c123gh6pm.h uart.c uart.h
