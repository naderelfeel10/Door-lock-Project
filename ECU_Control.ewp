# IAR project ECU_Control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\Control_ECU\MCAL; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project\Control_ECU\HAL; D:\DeepLearning\IAR_PROJECTS\Embedded\Door-Lock-Project
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 05-EEPROM-Demo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Control_ECU/Application
    Control_ECU/Application/: ECU_main.c
  group Control_ECU/HAL
    ./: Buzzer.c Buzzer.h motor.c motor.h
  group Control_ECU/MCAL
    ./: adc.c adc.h dio.c eeprom.c eeprom.h systick.c systick.h tm4c123gh6pm.h uart.c uart.h
    Control_ECU/MCAL/: dio.h
  group Library
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
  group Shared
    Shared/: uart.h
